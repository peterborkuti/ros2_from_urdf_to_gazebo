Commit message: movable robot with rviz2 and joint_state_publisher_gui

File: urdf/simple.urdf (robot description, URDF)
Before this commit: robot simple_robot, 2 links, 1 joints
Joints:
- joint base_body_joint: type fixed -> continuous
